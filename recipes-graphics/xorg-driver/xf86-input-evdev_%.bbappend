FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
        file://0001-Revert-Fix-handling-of-devices-with-only-buttons-e.g.patch \
"
