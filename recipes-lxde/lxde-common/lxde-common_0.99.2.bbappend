FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Always-launch-gpicview-in-fullscreen.patch \
            file://0001-Hide-the-taskbar-by-default.patch \
            "

